# Repository growth-team/GROWTH-FY2015-ADC-VersionB

File README.md:

#GROWTH-FY2015-ADC-VersionB

Eagle PCB design files of GROWTH-FY2015 ADC Board Version B.

Parts library "Aardvark.lbr" is required to open the schematic and the board files with eagle.

## EAGLE design ExtBoard.brd

Parts:
12V_OUT: LED_1608
C1, C2: 0.01u; 3216
C3, C5: 0.1u; 3216
C4: 68p; 3216
D2: 1N4148; 4020-2P
FUSE: FUSE_LITTLEFUSE_649; LITTLEFUSE_649
GAIN_AMP_OUT: TPPAD1-13; P1-13
GND: TPPAD1-13; P1-13
J_12V_IN: 2.1MMJACKTHM; PJ-102A
J_12V_OUT: IL-4P-S3EN2
J_+/-5V_IN: IL-3P-S3EN2
OUT: EPL.00.250.NTN
OUT2: IL-2P-S3EN2
PHOTO_DIODE: 1N4148; 4020-2P
PH_OUT: TPPAD1-13; P1-13
POLY_SW: R-US_0207/10; 0207/10
R1, R6: 100k; 2012
R2: 4.7k; 2012
R3, R4: 10k; 2012
R5: 1M; 2012
SJ1: SJ2WW; SJ_2W
U1, U2: LM6172SOIC(D)8; SOP8
VR1: 5k; ADJRP3-9.70XW5.0X9.80MM

Connections:
12V_FUSED: 12V_OUT.P$1 (A), FUSE.P$2, J_12V_OUT.P$1 (1), J_12V_OUT.P$2 (2), POLY_SW.2
+5V: C1.1, J_+/-5V_IN.P$1 (1), U1.8 (V+), U2.8 (V+)
+12V: FUSE.P$1, J_12V_IN.TIP, POLY_SW.1
-5V: C2.2, J_+/-5V_IN.P$3 (3), U1.4 (V-), U2.4 (V-)
GAIN1: C4.2, PHOTO_DIODE.1 (K), R1.2, U1.2 (-)
GAIN2: C3.2, C4.1, R1.1, U1.1 (OUT)
GAIN_AMP_OUT: GAIN_AMP_OUT.TP, R3.1, SJ1.3, U1.7 (OUT), VR1.1
GND: C1.2, C2.1, C5.1, GND.TP, J_12V_IN.RING, J_12V_OUT.P$3 (3), J_12V_OUT.P$4 (4), J_+/-5V_IN.P$2 (2), OUT.S1 (GND), OUT2.P$2 (2), PHOTO_DIODE.2 (A), R2.1, R4.1, R5.1, R6.1, U1.3 (+), U1.5 (+)
unnamed: OUT.1, OUT2.P$1 (1), SJ1.2
unnamed: U1.6 (-), VR1.2
unnamed: C5.2, D2.1 (K), R5.2, U2.5 (+)
unnamed: R3.2, R4.2, U2.3 (+)
unnamed: D2.2 (A), U2.1 (OUT)
unnamed: C3.1, R6.2, VR1.3
unnamed: 12V_OUT.P$2 (C), R2.2
PH_OUT: PH_OUT.TP, SJ1.1, U2.2 (-), U2.6 (-), U2.7 (OUT)

Notes on the sheet:
Fuse (12V over current protection)
Si photodiode sensor and amp
Peakhold
微分しない場合は shortさせる。
Gain Amp Out
微分しない場合は 未実装。

Board: 2 copper layers, 50.0 x 50.0 mm, 29 parts (1 on the bottom side), 16 nets.

Other parts of the board:
E$1: AARDVARK_LOGO

## EAGLE design G_FY2015_Mez.brd

Parts:
2.5V: TPPAD1-13; P1-13
C410: 1u; 3216
C411: 10u; 3216
J400: RPI2_GPIO_HOLES
J410, J411: IL-3P-S3EN2
JP_ADC: PINHD-2X2; 2X02
JP_LCD: LCD16X2
JP_SPI: PINHD-1X5; 1X05
J_I2C: IL-4P-S3EN2
J_UART: IL-3P-S3EN2
LED_RPI: SML-311WTT86; LED_1608
R400: 680; 2012
U410: MCP3208-CI/SL; SOIC-16(150MIL)(1.27MM)
U411: MCP1525TSOT-23-3; TSOT-23-3
U412, U413: LM60; TO-92-R2.5C
VR_CONT: 5k; ADJRP3-9.70XW5.0X9.80MM

Connections:
5V_PWR_ENADIS: J400.P$32 (GPIO12); also elsewhere on the board
+3V3: C410.2, J410.P$1 (1), J411.P$1 (1), J_I2C.P$1 (1), U410.16 (V_DD), U412.1 (VDD), U413.1 (VDD); also elsewhere on the board
+5V: JP_LCD.1 (VCC), U411.1 (VIN), VR_CONT.1; also elsewhere on the board
GND: C410.1, C411.1, J400.P$6 (GND), J400.P$9 (GND), J400.P$14 (GND), J400.P$20 (GND), J400.P$25 (GND), J400.P$30 (GND), J400.P$34 (GND), J400.P$39 (GND), J410.P$3 (3), J411.P$3 (3), JP_ADC.2, JP_ADC.4, JP_LCD.2 (GND), JP_LCD.5 (R/W), J_I2C.P$4 (4), J_UART.P$3 (3), LED_RPI.P$2 (C), U410.9 (DGND), U410.14 (AGND), U411.3 (VSS), U412.3 (GND), U413.3 (GND), VR_CONT.3; also elsewhere on the board
HV_PWR_ENADIS: J400.P$36 (GPIO16); also elsewhere on the board
LCD_D4: J400.P$31 (GPIO6), JP_LCD.11 (D4)
LCD_D5: J400.P$33 (GPIO13), JP_LCD.12 (D5)
LCD_D6: J400.P$35 (GPIO19), JP_LCD.13 (D6)
LCD_D7: J400.P$37 (GPIO26), JP_LCD.14 (D7)
LCD_ENA: J400.P$40 (GPIO21), JP_LCD.6 (ENABLE)
LCD_RS: J400.P$38 (GPIO20), JP_LCD.4 (RS)
LCD_V_CONT: JP_LCD.3 (V_CONT), VR_CONT.2
unnamed: LED_RPI.P$1 (A), R400.1
RPI_I2C_SCL: J400.P$5 (GPIO3), J_I2C.P$2 (2)
RPI_I2C_SDA: J400.P$3 (GPIO2), J_I2C.P$3 (3)
RPI_LED0: J400.P$29 (GPIO5), R400.2
RPI_OUT_FPGA_IN0: J400.P$7 (GPIO4); also elsewhere on the board
RPI_RX: J400.P$10 (GPIO15), J_UART.P$1 (1)
RPI_TX: J400.P$8 (GPIO14), J_UART.P$2 (2)
SLOWADC_0: U410.1 (CH0), U412.2 (VOUT)
SLOWADC_1: U410.2 (CH1), U413.2 (VOUT)
SLOWADC_2: J410.P$2 (2), U410.3 (CH2)
SLOWADC_3: J411.P$2 (2), U410.4 (CH3)
SLOWADC_4: U410.5 (CH4); also elsewhere on the board
SLOWADC_5: U410.6 (CH5); also elsewhere on the board
SLOWADC_6: JP_ADC.1, U410.7 (CH6)
SLOWADC_7: JP_ADC.3, U410.8 (CH7)
SPI_CE0: J400.P$24 (GPIO8), JP_SPI.4, U410.10 (!CS!/SHDN)
SPI_CE1: J400.P$26 (GPIO7), JP_SPI.5
SPI_MISO: J400.P$21 (GPIO9), JP_SPI.2, U410.12 (D_OUT)
SPI_MOSI: J400.P$19 (GPIO10), JP_SPI.3, U410.11 (D_IN)
SPI_SCLK: J400.P$23 (GPIO11), JP_SPI.1, U410.13 (CLK)
VREF_2V5: 2.5V.TP, C411.2, U410.15 (V_REF), U411.2 (VOUT)

Notes on the sheet:
Slow ADC
Raspberry Pi 2
Temperature sensors
General-purpose Analog Input
ADC Chip
Power/Vref 2.5V
LM60 sensors connected via cable
For PMT temp monitor
To outside pressure sensor (I2C)
16x2 LCD

Parts:
1PPS: TPPAD1-13; P1-13
AIN0+, AIN0-, AIN1+, AIN1-: TPPAD1-13; P1-13
C100, C110: 100p; C0805
C101, C111: 200p; C0805
C102, C103, C112, C113: 0.033u; C0805
C104, C106, C107, C108, C114, C116, C117, C118, C124, C126, C127, C128, C134, C136, C137, C138, C190, C192, C193, C195: 0.1u; C0805
C105, C109, C115, C119, C125, C129, C135, C139: 10u; C0805
C191, C194: 4.7u; C0805
C197: 0.01u; C0603
C198: 10u; 3216
GPIO0, GPIO1: TPPAD1-13; P1-13
IC100: FT232RL; SSOP28
IC101: FT245RL; SSOP28DB
J100, J110, J120, J130: EPL.00.250.NTN
J121, J131: IL-2P-S3EN2
J180: TOKUDEN_SP6
J181, J182: USB Mini-B Connector; MINIUSB5+4P-SMD-0.8-90D
P_OUT0, P_OUT1: TPPAD1-13; P1-13
R100, R105, R106, R109, R110, R115, R116, R119, R120, R125, R126, R130, R135, R136: 51; 2012
R101, R102, R103, R104, R111, R112, R113, R114, R121, R122, R123, R124, R131, R132, R133, R134: 510; 2012
R107, R117: 100k; 2012
R108, R118: 10k; 2012
R190: 3k; 2012
R191, R193: 1k; 2012
R192: 2k; 2012
R197, R198: 330; 2012
R_PZC0, R_PZC1: 56k; 2012
SJ100, SJ101, SJ110, SJ111: SJ2WW; SJ_2W
SJ_ADC_MODE: SJ2WW; SJ_2W
U100, U110, U120, U130: AD9215LONG_PAD; TSSOP-28(4.4MM)(0.65MM)_LONGPAD
U101, U111, U121, U131: AD8138; SOIC-8(150MIL)(1.27MM)
U102, U112: LM6172; SOP8
U191: GPS_FGPMMOPA6H
VR100, VR110: 5k; ADJRP3-9.70XW5.0X9.80MM
VR100P2, VR110P2: TPPAD1-13; P1-13
VREF0, VREF1, VREF2, VREF3: TPPAD1-13; P1-13

Connections:
+3V3: C108.2, C109.2, C118.2, C119.2, C128.2, C129.2, C138.2, C139.2, C192.1, C195.1, C197.2, C198.2, IC100.4 (VCCIO), IC101.4 (VCCIO), R190.1, R192.1, U100.7 (AVDD), U100.12 (AVDD), U100.24 (DRVDD), U101.3 (V+), U110.7 (AVDD), U110.12 (AVDD), U110.24 (DRVDD), U111.3 (V+), U120.7 (AVDD), U120.12 (AVDD), U120.24 (DRVDD), U121.3 (V+), U130.7 (AVDD), U130.12 (AVDD), U130.24 (DRVDD), U131.3 (V+), U191.P$1 (VCC), U191.P$2 (NRESET); also elsewhere on the board
+5V: C102.2, C112.2, C190.1, C191.1, C193.1, C194.1, IC100.20 (VCC), IC101.20 (VCC), U102.8 (V+), U112.8 (V+); also elsewhere on the board
-3V3: U101.6 (V-), U111.6 (V-), U121.6 (V-), U131.6 (V-); also elsewhere on the board
-5V: C103.2, C113.2, U102.4 (V-), U112.4 (V-); also elsewhere on the board
ADC0_CLK: J180.26 (B_23), U100.13 (CLK)
ADC0_D0: J180.1 (B_0), U100.17 (D0(LSB))
ADC0_D1: J180.2 (B_1), U100.18 (D1)
ADC0_D2: J180.3 (B_2), U100.19 (D2)
ADC0_D3: J180.4 (B_3), U100.20 (D3)
ADC0_D4: J180.5 (B_4), U100.21 (D4)
ADC0_D5: J180.6 (B_5), U100.22 (D5)
ADC0_D6: J180.7 (B_6), U100.25 (D6)
ADC0_D7: J180.8 (B_7), U100.26 (D7)
ADC0_D8: J180.9 (B_8), U100.27 (D8)
ADC0_D9: J180.10 (B_9), U100.28 (D9)
ADC0_VIN_N: AIN0-.TP, R106.1, U100.10 (VIN-)
ADC0_VIN_P: AIN0+.TP, R105.1, U100.9 (VIN+)
ADC1_CLK: J180.30 (B_25), U110.13 (CLK)
ADC1_D0: J180.11 (B_10), U110.17 (D0(LSB))
ADC1_D1: J180.12 (B_11), U110.18 (D1)
ADC1_D2: J180.13 (B_12), U110.19 (D2)
ADC1_D3: J180.14 (B_13), U110.20 (D3)
ADC1_D4: J180.15 (B_14), U110.21 (D4)
ADC1_D5: J180.16 (B_15), U110.22 (D5)
ADC1_D6: J180.19 (B_16), U110.25 (D6)
ADC1_D7: J180.20 (B_17), U110.26 (D7)
ADC1_D8: J180.21 (B_18), U110.27 (D8)
ADC1_D9: J180.22 (B_19), U110.28 (D9)
ADC1_VIN_N: AIN1-.TP, R116.1, U110.10 (VIN-)
ADC1_VIN_P: AIN1+.TP, R115.1, U110.9 (VIN+)
ADC2_CLK: J180.32 (B_27), U120.13 (CLK)
ADC2_D0: J180.57 (A_8), U120.17 (D0(LSB))
ADC2_D1: J180.58 (A_9), U120.18 (D1)
ADC2_D2: J180.61 (A_10), U120.19 (D2)
ADC2_D3: J180.62 (A_11), U120.20 (D3)
ADC2_D4: J180.63 (A_12), U120.21 (D4)
ADC2_D5: J180.64 (A_13), U120.22 (D5)
ADC2_D6: J180.65 (A_14), U120.25 (D6)
ADC2_D7: J180.66 (A_15), U120.26 (D7)
ADC2_D8: J180.67 (A_16), U120.27 (D8)
ADC2_D9: J180.68 (A_17), U120.28 (D9)
ADC2_VIN_N: R126.1, U120.10 (VIN-)
ADC2_VIN_P: R125.1, U120.9 (VIN+)
ADC3_CLK: J180.34 (B_29), U130.13 (CLK)
ADC3_D0: J180.71 (A_18), U130.17 (D0(LSB))
ADC3_D1: J180.72 (A_19), U130.18 (D1)
ADC3_D2: J180.73 (A_20), U130.19 (D2)
ADC3_D3: J180.74 (A_21), U130.20 (D3)
ADC3_D4: J180.75 (A_22), U130.21 (D4)
ADC3_D5: J180.76 (A_23), U130.22 (D5)
ADC3_D6: J180.77 (A_24), U130.25 (D6)
ADC3_D7: J180.78 (A_25), U130.26 (D7)
ADC3_D8: J180.79 (A_26), U130.27 (D8)
ADC3_D9: J180.80 (A_27), U130.28 (D9)
ADC3_VIN_N: R136.1, U130.10 (VIN-)
ADC3_VIN_P: R135.1, U130.9 (VIN+)
ADC_CM: R190.2, R191.1, U101.2 (CM), U111.2 (CM), U121.2 (CM), U131.2 (CM)
ADC_MODE: SJ_ADC_MODE.2, U100.2 (MODE), U110.2 (MODE), U120.2 (MODE), U130.2 (MODE)
ADC_PDWN: U100.14 (PDWN), U110.14 (PDWN), U120.14 (PDWN), U130.14 (PDWN)
AIN_0: J100.1, SJ100.3, SJ101.1
AIN_1: J110.1, SJ110.3, SJ111.1
AIN_2: J120.1, J121.P$1 (1), R120.2, R122.2
AIN_3: J130.1, J131.P$1 (1), R130.2, R132.2
FPGA_GPIO0: GPIO0.TP, J180.55 (A_6)
FPGA_GPIO1: GPIO1.TP, J180.56 (A_7)
FT232_RX_FPGA_TX: IC100.5 (RXD), J180.49 (A_0)
FT232_TX_FPGA_RX: IC100.1 (TXD), J180.50 (A_1)
FT245_/RE: IC101.13 (_RD), J180.52 (A_3)
FT245_/RXF: IC101.23 (_RXF), J180.24 (B_21)
FT245_/TXE: IC101.22 (_TXE), J180.23 (B_20)
FT245_D0: IC101.1 (D0), J180.25 (B_22)
FT245_D1: IC101.5 (D1), J180.29 (B_24)
FT245_D2: IC101.3 (D2), J180.31 (B_26)
FT245_D3: IC101.11 (D3), J180.33 (B_28)
FT245_D4: IC101.2 (D4), J180.35 (B_30)
FT245_D5: IC101.9 (D5), J180.37 (B_32)
FT245_D6: IC101.10 (D6), J180.53 (A_4)
FT245_D7: IC101.6 (D7), J180.54 (A_5)
FT245_WE: IC101.14 (WR), J180.51 (A_2)
GND: C102.1, C103.1, C106.2, C107.2, C108.1, C109.1, C112.1, C113.1, C116.2, C117.2, C118.1, C119.1, C126.2, C127.2, C128.1, C129.1, C136.2, C137.2, C138.1, C139.1, C190.2, C191.2, C192.2, C193.2, C194.2, C195.2, C197.1, C198.1, IC100.7 (GND), IC100.18 (GND), IC100.21 (GND), IC100.25 (GND), IC100.26 (TEST), IC101.7 (GND1), IC101.18 (GND2), IC101.21 (GND3), IC101.25 (AGND), IC101.26 (TEST), J100.S1 (GND), J110.S1 (GND), J120.S1 (GND), J121.P$2 (2), J130.S1 (GND), J131.P$2 (2), J180.27 (GND_3), J180.28 (GND_4), J180.47 (GND_5), J180.59 (GND_6), J180.60 (GND_7), J181.5 (GND), J181.P$1 (GND), J181.P$2 (GND), J181.P$3 (GND), J181.P$4 (GND), J182.5 (GND), J182.P$1 (GND), J182.P$2 (GND), J182.P$3 (GND), J182.P$4 (GND), R100.1, R101.1, R108.2, R110.1, R111.1, R118.2, R120.1, R121.1, R130.1, R131.1, R191.2, R193.2, SJ_ADC_MODE.1, U100.3 (SENSE), U100.8 (AGND), U100.11 (AGND), U100.23 (DGND), U102.3 (+), U110.3 (SENSE), U110.8 (AGND), U110.11 (AGND), U110.23 (DGND), U112.3 (+), U120.3 (SENSE), U120.8 (AGND), U120.11 (AGND), U120.23 (DGND), U130.3 (SENSE), U130.8 (AGND), U130.11 (AGND), U130.23 (DGND), U191.P$3 (GND), U191.P$8 (GND), U191.P$12 (GND), U191.P$19 (GND), VR100.1, VR110.1; also elsewhere on the board
GPS_1PPS: 1PPS.TP, J180.38 (B_33), U191.P$13 (1PPS)
GPS_RX_FPGA_TX: J180.40 (B_35), R198.2
GPS_TX_FPGA_RX: J180.39 (B_34), R197.2
unnamed: R101.2, R103.2, U101.1 (-)
unnamed: U100.4 (VREF), VREF0.TP
unnamed: C104.2, C105.2, C106.1, U100.6 (REFT)
unnamed: U110.4 (VREF), VREF1.TP
unnamed: C114.2, C115.2, C116.1, U110.6 (REFT)
unnamed: C104.1, C105.1, C107.1, U100.5 (REFB)
unnamed: C114.1, C115.1, C117.1, U110.5 (REFB)
unnamed: U120.4 (VREF), VREF2.TP
unnamed: C124.2, C125.2, C126.1, U120.6 (REFT)
unnamed: C124.1, C125.1, C127.1, U120.5 (REFB)
unnamed: U130.4 (VREF), VREF3.TP
unnamed: C134.2, C135.2, C136.1, U130.6 (REFT)
unnamed: C134.1, C135.1, C137.1, U130.5 (REFB)
unnamed: R102.1, R104.2, U101.8 (+)
unnamed: R111.2, R113.2, U111.1 (-)
unnamed: R104.1, R106.2, U101.5 (O-)
unnamed: R103.1, R105.2, U101.4 (O+)
unnamed: R112.1, R114.2, U111.8 (+)
unnamed: R114.1, R116.2, U111.5 (O-)
unnamed: R113.1, R115.2, U111.4 (O+)
unnamed: R121.2, R123.2, U121.1 (-)
unnamed: R122.1, R124.2, U121.8 (+)
unnamed: R124.1, R126.2, U121.5 (O-)
unnamed: R123.1, R125.2, U121.4 (O+)
unnamed: R131.2, R133.2, U131.1 (-)
unnamed: R132.1, R134.2, U131.8 (+)
unnamed: R134.1, R136.2, U131.5 (O-)
unnamed: R133.1, R135.2, U131.4 (O+)
unnamed: J180.17 (V33_1), J180.18 (V33_2), J180.69 (V33_3), J180.70 (V33_4)
unnamed: C100.2, C101.1, R107.1, R_PZC0.1, U102.1 (OUT)
unnamed: C101.2, R108.1, R_PZC0.2, U102.5 (+)
unnamed: R197.1, U191.P$9 (TX)
unnamed: C110.2, C111.1, R117.1, R_PZC1.1, U112.1 (OUT)
unnamed: U112.6 (-), VR110.2, VR110P2.TP
unnamed: C111.2, R118.1, R_PZC1.2, U112.5 (+)
unnamed: R198.1, U191.P$10 (RX)
unnamed: U102.6 (-), VR100.2, VR100P2.TP
unnamed: R119.2, U112.7 (OUT), VR110.3
unnamed: R192.2, R193.1, SJ_ADC_MODE.3
unnamed: R109.2, U102.7 (OUT), VR100.3
unnamed: R109.1, SJ100.1
unnamed: R119.1, SJ110.1
unnamed: C110.1, R117.2, SJ111.2, U112.2 (-)
unnamed: C100.1, R107.2, SJ101.2, U102.2 (-)
PREAMP0_OUT: P_OUT0.TP, R100.2, R102.2, SJ100.2
PREAMP1_OUT: P_OUT1.TP, R110.2, R112.2, SJ110.2
RPI_OUT_FPGA_IN0: J180.36 (B_31); also elsewhere on the board
USB_D_M: IC100.16 (USBDM), J181.2 (DM)
USB_D_M2: IC101.16 (USBDM), J182.2 (DM)
USB_D_P: IC100.15 (USBDP), J181.3 (DP)
USB_D_P2: IC101.15 (USBDP), J182.3 (DP)

Notes on the sheet:
ADC Common Mode Voltage
GPS Module
USB-UART
FPGA
ADC
Single-end-to-differential Amp
Pre Amplifier for PMT
ADC Mode selection
オープンにするとADC内部でpull downされ、「Offset binary」＋「Duty-ratio stabilizer disabled」で動作。
本当はR100, R105, R106=49.9オーム
本当はR101=523オーム
本当はR102, R103, R104=499オーム
SENSEピンをGNDに落としているので、 differential spanは2V (±1V)で、Vref=1Vとなる。

Parts:
J300, J301: SHV_PIGTAIL_LAND
LED_HV: SML-311WTT86; LED_1608
R300: 47k; 2012
R301, R302, R303: 4.7k; 2012
U300, U301: OPTON_1PA_12; OPTON_PA
U302: 2SC1815; TO-92-R2.5C
U303: 2SJ681; 2-7J2B
VR300, VR301: 5k; ADJRP3-9.70XW5.0X9.80MM
VR_HV0, VR_HV1: TPPAD1-13; P1-13

Connections:
+12V: R300.2, U303.P$3 (S); also elsewhere on the board
GND: J300.P$2 (GND), J301.P$2 (GND), LED_HV.P$2 (C), R302.2, U300.P$2 (GND), U300.P$6 (HV_GND), U300.P$8 (GND_CASE1), U300.P$9 (GND_CASE2), U301.P$2 (GND), U301.P$6 (HV_GND), U301.P$8 (GND_CASE1), U301.P$9 (GND_CASE2), U302.1 (E), VR300.1, VR301.1; also elsewhere on the board
HV_PWR_12V: R303.2, U300.P$1 (VIN), U301.P$1 (VIN), U303.P$2 (D)
HV_PWR_ENADIS: R301.2; also elsewhere on the board
unnamed: J300.P$1 (HV), U300.P$7 (HV_OUT)
unnamed: U300.P$3 (VR_OR_VCON), VR300.2, VR_HV0.TP
unnamed: J301.P$1 (HV), U301.P$7 (HV_OUT)
unnamed: U300.P$4 (VR_OR_NC), VR300.3
unnamed: U301.P$3 (VR_OR_VCON), VR301.2, VR_HV1.TP
unnamed: U301.P$4 (VR_OR_NC), VR301.3
unnamed: LED_HV.P$1 (A), R303.1
unnamed: R300.1, U302.2 (C), U303.P$1 (G)
unnamed: R301.1, R302.1, U302.3 (B)

Notes on the sheet:
HVPS Modules
HV 12V Power Control (from Raspberry Pi)
Vf=1.8V / I_F=2mA
