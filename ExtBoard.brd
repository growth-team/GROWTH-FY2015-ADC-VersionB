# Repository growth-team/GROWTH-FY2015-ADC-VersionB (continued)

## EAGLE design G_FY2015_Mez.brd (continued)

Parts:
-3V, -5V: TPPAD1-13; P1-13
C600, C610: 100u; E2,5-5
C601, C611, C620, C621, C623, C624: 10u; 3216
C622, C625: 1u; 3216
GND: TPPAD1-13; P1-13
J600_12V, J650_VOUT: IL-4P-S3EN2
J610: 2.1MMJACKTHM; PJ-102A
J620: IL-2P-S3EN2
J630, J640: USB_TYPEA_LUMBERG_2410_01; LUMBERG_2410-01
LED_5V, LED_5V_SW: SML-311WTT86; LED_1608
R500, R510: 0.01; R_LVR03
R501, R511: 100; 2012
R502, R512: 10k; 2012
R520: 47k; 2012
R521, R522: 4.7k; 2012
R523, R601: 1.5k; 2012
R600: 270; 2012
R610: 2k; 2012
TP_GND, TP_GND2: TPPAD1-13; P1-13
U500, U510: LT6106; TSOT-5
U520: 2SC1815; TO-92-R2.5C
U521: 2SJ681; 2-7J2B
U600, U610: PHT12050WAH; PHT12050
U620: LTC1983ES6-3; SOT-23
U621: LTC1983ES6-5; SOT-23

Connections:
5V_PWR_ENADIS: R521.2; also elsewhere on the board
5V_SW_OUT: J630.VBUS (VCC), R523.2, U521.P$2 (D)
+3V3: J650_VOUT.P$2 (2), R510.P$1, U510.4 (+); also elsewhere on the board
+3V3_BEFORE_SENSE: R510.P$2, R511.1, U510.5 (V+), U610.P$6 (V_O)
+5V: C620.2, C623.2, J620.P$1 (1), J640.VBUS (VCC), J650_VOUT.P$1 (1), R500.P$1, R520.2, R601.2, U500.4 (+), U521.P$3 (S), U620.1 (VCC), U620.6 (/SHDN), U621.1 (VCC), U621.6 (/SHDN); also elsewhere on the board
+5V_BEFORE_SENSE: R500.P$2, R501.1, U500.5 (V+), U600.P$6 (V_O)
+12V: C600.+, C601.2, C610.+, C611.2, J600_12V.P$1 (1), J600_12V.P$2 (2), J610.TIP, U600.P$2 (TRACK), U600.P$3 (V_I), U610.P$2 (TRACK), U610.P$3 (V_I); also elsewhere on the board
-3V3: -3V.TP, C621.1, U620.2 (VOUT); also elsewhere on the board
-5V: -5V.TP, C624.1, J650_VOUT.P$3 (3), U621.2 (VOUT); also elsewhere on the board
GND: C600.-, C601.1, C610.-, C611.1, C620.1, C621.2, C623.1, C624.2, GND.TP, J600_12V.P$3 (3), J600_12V.P$4 (4), J610.RING, J620.P$2 (2), J630.GND, J630.GND1 (GND), J630.GND2 (GND), J640.GND, J640.GND1 (GND), J640.GND2 (GND), J650_VOUT.P$4 (4), LED_5V.P$2 (C), LED_5V_SW.P$2 (C), R502.1, R512.1, R522.2, R600.1, R610.1, TP_GND.TP, TP_GND2.TP, U500.2 (V-), U510.2 (V-), U520.1 (E), U600.P$1 (GND), U610.P$1 (GND), U620.5 (GND), U621.5 (GND); also elsewhere on the board
unnamed: R501.2, U500.3 (-)
unnamed: R511.2, U510.3 (-)
unnamed: LED_5V.P$1 (A), R601.1
unnamed: R610.2, U610.P$5 (ADJUST)
unnamed: R520.1, U520.2 (C), U521.P$1 (G)
unnamed: R521.1, R522.1, U520.3 (B)
unnamed: LED_5V_SW.P$1 (A), R523.1
unnamed: C622.2, U620.3 (C+)
unnamed: C622.1, U620.4 (C-)
unnamed: R600.2, U600.P$5 (ADJUST)
unnamed: C625.1, U621.4 (C-)
unnamed: C625.2, U621.3 (C+)
SLOWADC_4: R502.2, U500.1 (OUT); also elsewhere on the board
SLOWADC_5: R512.2, U510.1 (OUT); also elsewhere on the board

Notes on the sheet:
Current Sense Amp
DCDC Modules
Power Connectors (input)
DCDC +12V=>+5V
DCDC +12V=>+3.3V
DCDC +5V=>-3V
Power Connectors (output)
パイロットランプ(5V)
本当はR600=280オーム
DCDC +5V=>--5V
5V On/Off from Raspberry Pi
Vf=1.8V I_F=2mA

Board: 4 copper layers, 160.0 x 100.0 mm, 203 parts (66 on the bottom side), 189 nets.

## Commit log

2015-05-14 first commit on 20150514_1112
2015-05-14 G_FY2015_Mez.sch - completed first drafting
2015-05-14 G_FY2015_Mez.brd - partially placed
2015-05-18 first board layout completed
2015-05-18 board layout completed, 100% routerd, logo inserted
2015-05-18 screenshots added
2015-05-18 GNDA and AGND removed (just use GND)
2015-05-18 GND plane introduced to top/bottom
2015-05-19 G_FY2015_Mez.brd - GROWTH logo added to the board
2015-05-19 +5V_BEFORE_SENSE and +3V3_BEFORE_SENSE properly connected (previously they were not connected)
2015-05-19 power connection manually routed in the board design
2015-05-19 routing modified (GND plane not introduced)
2015-05-28 P-ban.com submitted version
2015-09-04 version 20150904 (placement completed; before replacing with complementray SMD resistor and cap)
2015-09-11 as of 20150911 (4ch, FT232RL) before adding FT245 for higher data transfer rate
2015-10-13 version B completed. before autoroute for P-ban submit
2015-10-13 Ch.0 and Ch.1 connector modified, slow ADC and Ras Pi locations modified
2015-10-13 VR_CONT location modified
2015-10-13 LM60 (near DCDC) moved. Hand wiring necessary while integration
2015-10-13 P板.comに注文した時のバージョン
2015-10-14 netclass "power" added, and supply/gnd signals changed to "power" net
2015-10-14 routed for 2nd submit (supply/gnd have thicker connections)
2015-10-14 Raspberry Pi tPlace => bDocument (update for 2nd submit to p-ban.com)
2015-10-14 2nd submit to p-ban.com
    - solder stop masks
    - Raspberry Pi 2 tPlace => bDocu
    - thickness of supply/gnd connections
2015-10-14 parts list version 2 (following comments from p-ban.com)
2015-10-21 ExtBoard (fuse + si photo-diode amp) added. ExtBoard_Gerber_20151021_0010 submitted to Elecrow.
2016-02-24 README.md - newly added for github
